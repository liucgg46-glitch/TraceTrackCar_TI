# Keil uVision project TraceTrackCar_TI.uvprojx, settings and files
target TraceTrackCar_TI (6240000::V6.24::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  pack: TexasInstruments.MSPM0GX51X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20100000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x00400000,0x00080000) XRAM(0x20200000,0x00020000) XRAM2(0x20300000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TraceTrackCar_TI +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ..\User\Core;..\User\Config;..\User\Common;..\User\APP;..\User\BSP;..\User\Driver;..\User\Algorithm;..\User\Route;..\User\Test;..\User\VL53L1_core;..\User\VL53L1_platform;D:\TI\CCS\mspm0_sdk_2_11_00_07\source;D:\TI\CCS\mspm0_sdk_2_11_00_07\source\third_party\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x80000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20100000 size 0x10000
  scatter file: .\mspm0g3519.sct
  group User
    ../User/Core/: main.c
    ../User/Config/: empty_mspm0g3519.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g351x_uvision.s
  group Common
    ../User/Common/: project_critical.h project_status.h
  group BSP
    ../User/BSP/: bsp_adc.c bsp_adc.h bsp_all.c bsp_all.h bsp_common.c bsp_common.h bsp_encoder.c bsp_encoder.h bsp_exti.c bsp_exti.h bsp_gpio.c bsp_gpio.h bsp_i2c.c bsp_i2c.h bsp_key.c bsp_key.h bsp_pwm.c bsp_pwm.h bsp_spi.c bsp_spi.h bsp_systick.c bsp_systick.h bsp_uart.c bsp_uart.h vehicle_config.h
  group Algorithm
    ../User/Algorithm/: attitude_estimator.c attitude_estimator.h control_config.h heading_estimator.c heading_estimator.h line_detect.c line_detect.h line_track.c line_track.h odometer.c odometer.h pid.c pid.h
  group Driver
    ../User/Driver/: driver_all.c driver_all.h drv_buzzer.c drv_buzzer.h drv_e220.c drv_e220.h drv_encoder.c drv_encoder.h drv_gray_4051.c drv_gray_4051.h drv_gray_mcu_i2c.c drv_gray_mcu_i2c.h drv_gray_sensor.c drv_gray_sensor.h drv_hx711.c drv_hx711.h drv_icm20948.c drv_icm20948.h drv_laser.c drv_laser.h drv_lcd_font.c drv_lcd_font.h drv_lcd_image.h drv_lcd_tft.c drv_lcd_tft.h drv_motor.c drv_motor.h drv_oled_font.c drv_oled_font.h drv_oled_i2c.c drv_oled_i2c.h drv_oled_image.c drv_oled_image.h drv_servo.c drv_servo.h drv_status_light.c drv_status_light.h drv_vl53l1x.c drv_vl53l1x.h
  group Test
    ../User/Test/: test.c test.h test_config.h test_k210_comm.c test_k210_comm.h
  group APP
    ../User/APP/: app_all.c app_all.h app_diagnostics.c app_diagnostics.h app_task_config.h app_task_port.c app_task_port.h chassis.c chassis.h gimbal_app.c gimbal_app.h k210_comm.c k210_comm.h lcd_ui.c lcd_ui.h line_calibration.c line_calibration.h line_follow_app.c line_follow_app.h motion_action.c motion_action.h nb_wait.c nb_wait.h odometer_adapter.c odometer_adapter.h oled_ui.c oled_ui.h scheduler.c scheduler.h sensor_manager.c sensor_manager.h task_fsm.c task_fsm.h task_profile_config.h task_profile_select.c task_profile_select.h
  group Route
    ../User/Route/: route_common.c route_common.h route_config.h route_manager.c route_manager.h route_profile_basic.c route_profile_basic.h route_profile_medicine.c route_profile_medicine.h route_profile_select.c route_profile_select.h
  group VL53L1_core
    ../User/VL53L1_core/: VL53L1X_api.c VL53L1X_api.h VL53L1X_calibration.c VL53L1X_calibration.h
  group VL53L1_platform
    ../User/VL53L1_platform/: vl53l1_platform.c vl53l1_platform.h vl53l1_platform_config.h vl53l1_types.h
  group Driverlib
    D:/TI/CCS/mspm0_sdk_2_11_00_07/source/ti/driverlib/lib/keil/m0p/mspm0gx51x/: driverlib.a
